# Keil uVision project Blinky.uvprojx, settings and files
target CMSIS-DAP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MKL25Z128xxx4 Freescale Semiconductor
  pack: Keil.Kinetis_KLxx_DFP.1.11.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x3000) IRAM2(0x1FFFF000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
  group Source Files
    ./: Blinky.c TIspi.h
  group Documentation
    ./: Abstract.txt
target CMSIS-DAP-MTB (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
software components: CMSIS:CORE 3.20.0, Device:Startup 2.5.0
